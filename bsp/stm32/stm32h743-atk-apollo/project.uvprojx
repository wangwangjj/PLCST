# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARMLIBC, USE_HAL_DRIVER, STM32H743xx, RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\finsh;packages\RyanW5500-latest\platform\RT-Thread;..\..\..\components\utilities\ulog;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;.;packages\RyanW5500-latest\ioLibrary\wizchip;..\..\..\libcpu\arm\common;packages\RyanW5500-latest\ioLibrary\W5500;..\..\..\components\net\netdev\include;..\..\..\components\net\sal\include;packages\RyanW5500-latest\common;..\..\..\components\drivers\include;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers\drivers;..\..\..\components\libc\posix\io\epoll;..\libraries\HAL_Drivers\drivers\config;packages\RyanW5500-latest\ioLibrary;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\libraries\HAL_Drivers;board;..\..\..\components\net\sal\include\socket;packages\RyanW5500-latest\example;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\libcpu\arm\cortex-m7;packages\RyanW5500-latest\W5500Client;packages\RyanW5500-latest\ioLibrary\DNS;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\..\..\components\libc\posix\io\eventfd;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\libc\compilers\common\include;packages\RyanW5500-latest\ioLibrary\DHCP
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c drv_mpu.c
  group Finsh
    ../../../components/finsh/: shell.c msh_parse.c cmd.c msh.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_crc.c stm32h7xx_hal_cryp.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_rcc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_sram.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rng.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_comp.c stm32h7xx_hal_cec.c stm32h7xx_hal_pwr.c stm32h7xx_hal_dma.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group RyanW5500
    packages/RyanW5500-latest/W5500Client/: RyanW5500.c RyanW5500Socket.c RyanW5500Ping.c RyanW5500Store.c RyanW5500netDev.c
    packages/RyanW5500-latest/ioLibrary/wizchip/: wizchip_socket.c wizchip_conf.c
    packages/RyanW5500-latest/ioLibrary/DHCP/: wizchip_dhcp.c
    packages/RyanW5500-latest/ioLibrary/W5500/: w5500.c
    packages/RyanW5500-latest/example/: RyanW5500Test.c
    packages/RyanW5500-latest/common/: RyanList.c
    packages/RyanW5500-latest/platform/RT-Thread/: platformTimer.c platformW5500Hardware.c
    packages/RyanW5500-latest/ioLibrary/DNS/: wizchip_dns.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/socket/: net_netdb.c
    ../../../components/net/sal/src/: sal_socket.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
